# Keil uVision project test.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\code
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Main
    ./code/: main.c system_LPC177x_8x.c startup_LPC177x_8x.s Retarget.c parser.c parser.h
  group DRV
    ./code/drv/: drv_sdram.c drv_lcd.c drv_uart.c drv_general.c drv_touchscreen.c gl_fonts.c drv_led.c wiznet.c wiznet_io.c wiznet_print.c
  group utils
    ./code/utils/: ringbuf.c timer_software.c timer_software_init.c
